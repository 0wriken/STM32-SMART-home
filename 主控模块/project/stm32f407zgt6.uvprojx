# Keil uVision project stm32f407zgt6.uvprojx, settings and files
target stm32f407zgt6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407zgt6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\cmsis\inc;..\user\inc;..\ucosii_core\inc;..\ucosii_task\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ../cmsis/src/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
  group user
    ../user/src/: main.c led.c UART.c pwm_out.c tim_in.c ili9486.c delay.c touch.c can.c
    ../user/inc/: uart.h ili9486.h touch.h pic.h Can.h
  group ucosii_core
    ../ucosii_core/src/: os_core.c os_cpu_c.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cpu_a.asm
    ../ucosii_task/src/: play_task.c
    ../ucosii_core/inc/: os.h os_cfg.h os_cpu.h ucos_ii.h
  group ucosii_task
    ../ucosii_task/src/: start_task.c lcd_task.c check_task.c play_task.c water_task.c sun_task.c
    ../ucosii_task/inc/: start_task.h
