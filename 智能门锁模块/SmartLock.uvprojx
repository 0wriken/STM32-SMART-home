# Keil uVision project SmartLock.uvprojx, settings and files
target SmartLock (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartLock
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\user\inc;.\cmsis;.\UCOSII\Source;.\UCOSII\ports;.\task
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ./cmsis/: system_stm32f10x.c startup_stm32f10x_hd.s
  group user
    ./user/src/: main.c uart.c delay.c iic.c at24c02.c MPR121.c spi.c oled.c led.c monochome_oled.c oled_memory.c funtion.c MG200.c time.c
    ./user/inc/: uart.h funtion.h monochome_oled.h MPR121.h time.h
  group ucosii
    ./UCOSII/Source/: os_cfg.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
    ./UCOSII/ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group task
    ./task/: start_task.c open_door.c GetPwTask.c EnterRootTask.c CheckPwTask.c RootFutionTask.c OpenFailTask.c task.h
    ./user/inc/: funtion.h
